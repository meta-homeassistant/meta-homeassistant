inherit setuptools3
require python-mystrom.inc
