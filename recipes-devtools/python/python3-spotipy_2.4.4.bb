inherit setuptools3
require python-spotipy.inc
