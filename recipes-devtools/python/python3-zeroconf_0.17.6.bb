inherit setuptools3
require python-zeroconf.inc
