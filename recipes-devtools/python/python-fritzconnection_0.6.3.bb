inherit setuptools
require python-fritzconnection.inc
