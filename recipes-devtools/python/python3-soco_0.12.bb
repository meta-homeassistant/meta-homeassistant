inherit setuptools3
require python-soco.inc
