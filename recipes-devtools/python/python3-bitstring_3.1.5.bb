inherit setuptools3
require python-bitstring.inc
