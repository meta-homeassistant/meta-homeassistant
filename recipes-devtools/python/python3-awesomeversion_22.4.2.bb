SUMMARY = "Make anything a version object, and compare against a vast section of other version formats."
HOMEPAGE = "https://github.com/ludeeus/awesomeversion"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENCE.md;md5=92622b5a8e216099be741d78328bae5d"

inherit pypi setuptools3

SRC_URI[md5sum] = "d0583a382374a89722c8b268dc1ccc9a"
SRC_URI[sha256sum] = "2aa3d42a15b984542b1b9c61cf1220879face4298a4cc894678a1d79a3618182"

