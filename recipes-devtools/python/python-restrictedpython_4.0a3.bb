inherit setuptools
require python-restrictedpython.inc
