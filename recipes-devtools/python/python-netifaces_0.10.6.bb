inherit setuptools
require python-netifaces.inc
