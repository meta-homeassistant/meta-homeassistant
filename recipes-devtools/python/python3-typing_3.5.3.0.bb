inherit setuptools3
require python-typing.inc
