inherit setuptools3
require python-python-slugify.inc
