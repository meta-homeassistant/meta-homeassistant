inherit setuptools
require python-google-api-python-client.inc
