inherit setuptools3
require python-python-telegram-bot.inc
