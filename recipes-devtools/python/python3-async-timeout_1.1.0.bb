SUMMARY = "Timeout context manager for asyncio programs"
HOMEPAGE = "https://github.com/aio-libs/async_timeout/"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e3fc50a88d0a364313df4b21ef20c29e"

inherit pypi setuptools3

SRC_URI[md5sum] = "8c3565e165266dd7710a76f50ae44319"
SRC_URI[sha256sum] = "b88bd1fe001b800ec23c7bf27a81b32819e2a56668e9fba5646a7f3618143081"
