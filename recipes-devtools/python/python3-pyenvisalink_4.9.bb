SUMMARY = "A python3 library for running asynchronus communications with envisalink alarm control panel modules."
HOMEPAGE = "https://github.com/ufodone/pyenvisalink"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=7bda0925566c1a0dc0b380d4ede12e07"
RECIPE_MAINTAINER = "Tom Geelen <t.f.g.geelen@gmail.com>"

SRC_URI[sha256sum] = "5ad068a4b50202b58ce09c00e75edb9d889d7cec2a537bfb0296426ec32e63fa"

inherit pypi setuptools3
