inherit setuptools3
require python-influxdb.inc
