SUMMARY = "aiolifx light effectso"
HOMEPAGE = "https://github.com/amelchio/aiolifx_effects"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=751cf730c9b4efcac8032196afacf6f8"

PYPI_PACKAGE = "aiolifx_effects"

inherit pypi setuptools3

SRC_URI[md5sum] = "064e3bc0e2e33f7bc4948a2803a0e976"
SRC_URI[sha256sum] = "05207137275722a020666e499cc2d48d6808851770f824470614265ad4a1eb06"
