inherit setuptools
require python-voluptuous.inc
