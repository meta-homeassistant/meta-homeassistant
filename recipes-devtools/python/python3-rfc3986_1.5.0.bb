SUMMARY = "A Python Implementation of RFC3986 including validations"
HOMEPAGE = "https://github.com/python-hyper/rfc3986"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=03731a0e7dbcb30cecdcec77cc93ec29"

SRC_URI[md5sum] = "0e3a03c3eb3b679d5a253b168bb5774a"
SRC_URI[sha256sum] = "270aaf10d87d0d4e095063c65bf3ddbc6ee3d0b226328ce21e036f946e421835"

inherit pypi setuptools3
