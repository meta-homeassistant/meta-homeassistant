inherit setuptools3
require python-forecastio.inc

