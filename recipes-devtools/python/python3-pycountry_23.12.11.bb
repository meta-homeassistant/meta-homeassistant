SUMMARY = "A Python library to access ISO country, subdivision, language, currency and script definitions and their translations."
HOMEPAGE = "https://github.com/flyingcircusio/pycountry"
LICENSE = "LGPL-2.1-only"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=8cf1799061bb2f68625332ab7039e11f"

SRC_URI[sha256sum] = "00569d82eaefbc6a490a311bfa84a9c571cff9ddbf8b0a4f4e7b4f868b4ad925"

inherit pypi python_poetry_core
