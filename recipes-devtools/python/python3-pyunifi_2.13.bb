inherit setuptools3
require python-pyunifi.inc
