LICENSE = "GPL-2.0-or-later"
LIC_FILES_CHKSUM = "file://COPYING;md5=b234ee4d69f5fce4486a80fdaf4a4263"

inherit pypi setuptools3

SRC_URI[md5sum] = "648c9f38b8ef46ffb0d5135524650b87"
SRC_URI[sha256sum] = "6e5f8ba84836b99fe60be5fb27f84be4ad919bbb6b49caa6ae81e70584b55e58"

