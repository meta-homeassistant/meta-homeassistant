SUMMARY = "An implementation of the Debug Adapter Protocol for Python"
HOMEPAGE = "https://github.com/microsoft/debugpy/"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=7b6b095fe2a2e2b66cb08d295b605789"

SRC_URI[sha256sum] = "e6355385db85cbd666be703a96ab7351bc9e6c61d694893206f8001e22aee091"

inherit pypi python_setuptools_build_meta

PYPI_PACKAGE_EXT = "zip"
