inherit setuptools3
require python-pymata.inc
