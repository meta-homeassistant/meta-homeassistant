inherit setuptools3
require python-restrictedpython.inc
