inherit setuptools3
require python-pydeconz.inc
