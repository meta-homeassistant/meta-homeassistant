SUMMARY = "Basic bluetooth models used by Home Assistant."
HOMEPAGE = "https://pypi.org/project/home-assistant-bluetooth/"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c624803bdf6fc1c4ce39f5ae11d7bd05"

PYPI_PACKAGE = "home_assistant_bluetooth"

inherit pypi setuptools3

SRC_URI[md5sum] = "524fe41bd19018f8d5c4759e36d9cd8f"
SRC_URI[sha256sum] = "673115b2109e802f73ce0ac70dbc13a6011372c1e0ad5aa27cce7d13fd4a00d0"

