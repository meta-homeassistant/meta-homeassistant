inherit setuptools
require python-pyunifi.inc
