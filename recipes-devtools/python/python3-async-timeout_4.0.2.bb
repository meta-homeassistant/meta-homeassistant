SUMMARY = "asyncio-compatible timeout class"
HOMEPAGE = "https://github.com/aio-libs/async-timeout"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=4fa41f15bb5f23b6d3560c5845eb8d57"

SRC_URI[md5sum] = "10571272b2e0fab839ec23f8293bf482"
SRC_URI[sha256sum] = "2163e1640ddb52b7a8c80d0a67a08587e5d245cc9c553a74a847056bc2976b15"

inherit pypi python_setuptools_build_meta
