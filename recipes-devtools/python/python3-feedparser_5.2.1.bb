inherit setuptools3
require python-feedparser.inc

