inherit setuptools
require python-fuzzywuzzy.inc
