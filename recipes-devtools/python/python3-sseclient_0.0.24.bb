inherit setuptools3
require python-sseclient.inc

