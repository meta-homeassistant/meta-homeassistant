SUMMARY = "A Python library to access ISO country, subdivision, language, currency and script definitions and their translations."
HOMEPAGE = "https://github.com/flyingcircusio/pycountry"
LICENSE = "LGPL-2.1-only"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=8cf1799061bb2f68625332ab7039e11f"
RECIPE_MAINTAINER = "Tom Geelen <t.f.g.geelen@gmail.com>"

SRC_URI[sha256sum] = "b61b3faccea67f87d10c1f2b0fc0be714409e8fcdcc1315613174f6466c10221"

inherit pypi python_poetry_core
