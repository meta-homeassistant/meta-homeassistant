inherit setuptools3
require python-mutagen.inc
