inherit setuptools
require python-pymata.inc
