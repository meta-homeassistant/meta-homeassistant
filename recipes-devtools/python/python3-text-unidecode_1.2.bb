SUMMARY = "Python implementation of ua-parser "
HOMEPAGE = "https://github.com/ua-parser/uap-python"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://LICENSE;md5=323885a59e4cba72dba895e0c696592a"

inherit pypi setuptools3

SRC_URI[md5sum] = "af781f1268527a039bf7b2935a20e6b9"
SRC_URI[sha256sum] = "5a1375bb2ba7968740508ae38d92e1f889a0832913cb1c447d5e2046061a396d"

