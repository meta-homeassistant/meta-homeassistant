SUMMARY = "AnyIO is an asynchronous networking and concurrency library that works on top of either asyncio or trio"
HOMEPAGE = "https://github.com/agronholm/anyio"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c0a769411d2af7894099e8ff75058c9f"

inherit python_setuptools_build_meta pypi

SRC_URI[md5sum] = "e8def29aa096045e250d9d9cf3f18e65"
SRC_URI[sha256sum] = "a0aeffe2fb1fdf374a8e4b471444f0f3ac4fb9f5a5b542b48824475e0042a5a6"

