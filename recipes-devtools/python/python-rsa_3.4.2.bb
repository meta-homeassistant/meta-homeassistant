inherit setuptools
require python-rsa.inc
