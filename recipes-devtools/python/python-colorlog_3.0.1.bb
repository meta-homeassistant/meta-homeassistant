inherit setuptools
require python-colorlog.inc
