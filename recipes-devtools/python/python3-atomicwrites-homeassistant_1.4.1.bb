SUMMARY = "Powerful Python library for atomic file writes. Fork from homeassistant"
HOMEPAGE = "https://pypi.org/project/atomicwrites-homeassistant/"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=91cc36cfafeefb7863673bcfcb1d4da4"
RECIPE_MAINTAINER = "Tom Geelen <t.f.g.geelen@gmail.com>"

inherit pypi setuptools3 ptest-python-pytest

SRC_URI[sha256sum] = "256a672106f16745445228d966240b77b55f46a096d20305901a57aa5d1f4c2f"
