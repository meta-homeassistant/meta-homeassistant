SUMMARY = "enum/enum34 compatibility package"
HOMEPAGE = "https://github.com/jstasiak/enum-compat"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=8;endline=8;md5=8227180126797a0148f94f483f3e1489"
RECIPE_MAINTAINER = "Tom Geelen <t.f.g.geelen@gmail.com>"

SRC_URI[sha256sum] = "3677daabed56a6f724451d585662253d8fb4e5569845aafa8bb0da36b1a8751e"

inherit pypi setuptools3

PYPI_PACKAGE = "enum-compat"
