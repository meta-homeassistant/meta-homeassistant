inherit setuptools3
require python-astral.inc
