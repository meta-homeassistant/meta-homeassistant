inherit setuptools3
require python-pyotp.inc
