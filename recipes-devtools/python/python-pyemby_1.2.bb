inherit setuptools
require python-pyemby.inc
