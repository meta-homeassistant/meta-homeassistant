inherit setuptools
require python-gtts-token.inc
