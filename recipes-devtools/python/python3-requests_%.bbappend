RDEPENDS:${PN} += "\
    python3-charset-normalizer \
"