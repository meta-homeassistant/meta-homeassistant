inherit setuptools3
require python-samsungctl.inc
