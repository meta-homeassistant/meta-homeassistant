SUMMARY = "Python wrapper for Fully Kiosk Browser REST API"
HOMEPAGE = "https://github.com/cgarwood/python-fullykiosk"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=86d3f3a95c324c9479bd8986968f4327"
RECIPE_MAINTAINER = "Tom Geelen <t.f.g.geelen@gmail.com>"

SRC_URI[sha256sum] = "b6c5a8888044d048819b9fad62e39313a7019c6e69374e3b04f5d5027b6bc300"

inherit pypi setuptools3
