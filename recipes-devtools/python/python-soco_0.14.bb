inherit setuptools
require python-soco.inc
