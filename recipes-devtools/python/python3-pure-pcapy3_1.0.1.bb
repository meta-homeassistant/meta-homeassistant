SUMMARY = "Pure Python reimplementation of pcapy. This package is API compatible and a drop-in replacement."
HOMEPAGE = "http://bitbucket.org/viraptor/pure-pcapy/overview"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=8;endline=8;md5=1051ab694c722be4ac182fc37d0020fb"

SRC_URI[sha256sum] = "b99e45f16d4ad410eb5ebbc7d5d39e353d7eda7e86f0ad52e4dc5c45a7b3ea92"

inherit pypi setuptools3
