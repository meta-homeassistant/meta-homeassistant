inherit setuptools
require python-bitstring.inc
