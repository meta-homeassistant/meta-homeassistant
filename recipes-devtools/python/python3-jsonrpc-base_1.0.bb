SUMMARY = "A JSON-RPC client library base interface"
HOMEPAGE = "http://github.com/armills/jsonrpc-base"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=9535ae79c9d2a6e803c0603c6e004747"

inherit pypi setuptools3

SRC_URI[md5sum] = "28d25afeab9bc84010c8cd0fe0774e6e"
SRC_URI[sha256sum] = "93fbe7fa174f66538cb83ca4f30e270a133d66b8e22a683a71b328488a2d85b6"
