inherit setuptools
require python-astral.inc
