inherit setuptools
require python-matrix-client.inc
