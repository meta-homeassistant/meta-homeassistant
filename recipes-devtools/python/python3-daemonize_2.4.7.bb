inherit setuptools3
require python-daemonize.inc

