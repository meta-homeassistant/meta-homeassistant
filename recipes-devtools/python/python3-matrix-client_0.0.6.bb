inherit setuptools3
require python-matrix-client.inc
