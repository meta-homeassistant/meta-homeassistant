inherit setuptools3
require python-voluptuous-serialize.inc
