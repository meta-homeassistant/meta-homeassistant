SUMMARY = "An Dict like LRU container."
HOMEPAGE = "https://github.com/amitdev/lru-dict"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=9d10a486ee04034fdef5162fd791f153"

inherit pypi setuptools3

SRC_URI[md5sum] = "855db58f7c909a0524c182076a3acc6b"
SRC_URI[sha256sum] = "45b81f67d75341d4433abade799a47e9c42a9e22a118531dcb5e549864032d7c"

