inherit setuptools
require python-mutagen.inc
