inherit setuptools3
require python-phue.inc
