inherit setuptools3
require python-gtts-token.inc
