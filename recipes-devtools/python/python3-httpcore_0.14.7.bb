SUMMARY = "HTTP Core"
HOMEPAGE = "https://github.com/encode/httpcore"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=1c1f23b073da202e1f4f9e426490210c"

inherit pypi setuptools3

SRC_URI[md5sum] = "6aa1c1b0cbd2e3b85a3bd7fd935a07ad"
SRC_URI[sha256sum] = "7503ec1c0f559066e7e39bc4003fd2ce023d01cf51793e3c173b864eb456ead1"

