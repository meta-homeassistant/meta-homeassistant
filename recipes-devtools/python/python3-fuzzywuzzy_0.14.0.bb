inherit setuptools3
require python-fuzzywuzzy.inc
