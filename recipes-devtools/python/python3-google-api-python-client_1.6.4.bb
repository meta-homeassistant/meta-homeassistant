inherit setuptools3
require python-google-api-python-client.inc
