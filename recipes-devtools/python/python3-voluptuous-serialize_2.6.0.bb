SUMMARY = "Convert Voluptuous schemas to dictionaries so they can be serialized."
HOMEPAGE = "http://github.com/balloob/voluptuous-serialize"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=dab31a1d28183826937f4b152143a33f"
RECIPE_MAINTAINER = "Tom Geelen <t.f.g.geelen@gmail.com>"

inherit setuptools3 pypi ptest-python-pytest

SRC_URI[md5sum] = "e94c0d555f3b8d2f2c92b540e5eda3d2"
SRC_URI[sha256sum] = "79acdc58239582a393144402d827fa8efd6df0f5350cdc606d9242f6f9bca7c4"
