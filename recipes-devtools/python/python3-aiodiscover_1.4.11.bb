SUMMARY = "Discover hosts by arp and ptr lookup"
HOMEPAGE = "https://github.com/bdraco/aiodiscover"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=5c1e4dcca80a6a841c085ded9c25b768"

inherit pypi python_setuptools_build_meta

SRC_URI[md5sum] = "abe7b19fb0895996db14ea9746425789"
SRC_URI[sha256sum] = "f203036acb7cf4cf42798b42e7e0a4c3ec6999fe9dfdbff30b22934a8da3d354"

