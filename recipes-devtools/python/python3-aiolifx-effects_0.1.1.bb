SUMMARY = "aiolifx light effectso"
HOMEPAGE = "https://github.com/amelchio/aiolifx_effects"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=751cf730c9b4efcac8032196afacf6f8"

PYPI_PACKAGE = "aiolifx_effects"

inherit pypi setuptools3

SRC_URI[md5sum] = "c9ffebc66b4ae3408b97c63fa6ee7dd3"
SRC_URI[sha256sum] = "a4d9a40964f1617f546c2a324aa0319e9c31f4bed830b0ed46e0958d3bf8de7f"
