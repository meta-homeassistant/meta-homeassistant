inherit setuptools3
require python-transitions.inc
