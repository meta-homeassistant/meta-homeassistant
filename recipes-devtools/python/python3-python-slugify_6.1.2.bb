inherit setuptools3
require python-python-slugify.inc

SRC_URI[md5sum] = "aab9a932e64628675162b8f2d41a8235"
SRC_URI[sha256sum] = "272d106cb31ab99b3496ba085e3fea0e9e76dcde967b5e9992500d1f785ce4e1"
