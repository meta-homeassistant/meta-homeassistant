inherit setuptools
require python-pyotp.inc
