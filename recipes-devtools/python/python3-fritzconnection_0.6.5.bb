inherit setuptools3
require python-fritzconnection.inc
