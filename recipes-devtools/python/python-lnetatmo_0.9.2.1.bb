inherit setuptools
require python-lnetatmo.inc
