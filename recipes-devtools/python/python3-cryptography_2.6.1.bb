inherit setuptools3
require python-cryptography.inc
