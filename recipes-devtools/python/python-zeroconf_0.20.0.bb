inherit setuptools
require python-zeroconf.inc
