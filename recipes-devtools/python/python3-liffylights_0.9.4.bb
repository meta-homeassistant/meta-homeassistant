SUMMARY = "LIFX Python library"
HOMEPAGE = "https://github.com/TangoAlpha/liffylights"
LICENSE = "MIT"
# TODO: Use real license once: https://github.com/TangoAlpha/liffylights/issues/4 is fixed
#LIC_FILES_CHKSUM = "file://LICENSE;md5=d4ae7def6b740abc020a2700493fef4e"
LIC_FILES_CHKSUM = "file://setup.py;md5=d4ae7def6b740abc020a2700493fef4e"

inherit pypi setuptools3

SRC_URI[md5sum] = "422aa6e191ab9a6a2d4220544a7341d1"
SRC_URI[sha256sum] = "e7639c238ea83c6fcb34916c27c754911782798a6894a5e1eb0b409cb2c05da3"
