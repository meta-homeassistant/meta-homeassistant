inherit setuptools3
require python-lnetatmo.inc
