SUMMARY = "A JOSE implementation in Python using pycryptodome instead pycrypto."
HOMEPAGE = "http://github.com/capless/python-jose-cryptodome"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=1b2f485d31051eb5916a93212174c041"

#PYPI_PACKAGE = "python-slugify"

inherit pypi setuptools3

SRC_URI[md5sum] = "05a84308b9d74100ca5f0a52faf57a80"
SRC_URI[sha256sum] = "9226693ee9ff52795ea8bfc70e0b77c62dca9a0f0fcbf9635c248d190211826e"

