SUMMARY = "Platform-independent pure-Python module to get a MAC address"
HOMEPAGE = "https://github.com/GhostofGoes/getmac"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=49206937513d48371c7b19babc4ec77f"
RECIPE_MAINTAINER = "Tom Geelen <t.f.g.geelen@gmail.com>"

SRC_URI[sha256sum] = "8477755b69ff93a3b514b54e1fbb8ebb57d8f4e5c37e7c18bcef3a0f1f149232"

inherit pypi setuptools3
