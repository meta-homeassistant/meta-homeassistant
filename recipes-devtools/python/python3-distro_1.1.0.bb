inherit setuptools3
require python-distro.inc
