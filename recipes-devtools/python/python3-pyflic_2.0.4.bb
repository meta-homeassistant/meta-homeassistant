SUMMARY = "Python library to connect to and interact with Flic buttons."
HOMEPAGE = "https://github.com/soldag/pyflic"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=8;endline=8;md5=8227180126797a0148f94f483f3e1489"

SRC_URI[sha256sum] = "944e1a9b6adb99e4d3cf7784de4919e35781d9cb0a6cf53df2cab6c4af16d749"

inherit pypi setuptools3

PYPI_PACKAGE = "pyflic"
