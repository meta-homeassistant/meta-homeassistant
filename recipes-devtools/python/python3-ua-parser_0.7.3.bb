SUMMARY = "Python port of Browserscope's user agent parser"
HOMEPAGE = "https://github.com/ua-parser/uap-python"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=b3645b4ad6bca318833557c926dd13af"

inherit pypi setuptools3

SRC_URI[md5sum] = "d07b2eae4ef43fcf7b2011fbcee22bca"
SRC_URI[sha256sum] = "0aafb05a67b621eb4d69f6c1c3972f2d9443982bcd9132a8b665d90cd48a1add"
