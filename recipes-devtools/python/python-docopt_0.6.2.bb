inherit setuptools
require python-docopt.inc
