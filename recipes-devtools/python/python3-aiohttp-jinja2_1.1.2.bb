inherit setuptools3
require python-aiohttp-jinja2.inc

