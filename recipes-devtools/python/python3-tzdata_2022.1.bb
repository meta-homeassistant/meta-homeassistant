SUMMARY = "Provider of IANA time zone data"
HOMEPAGE = "https://github.com/python/tzdata"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fca9fd5c15a28eb874ba38577a585d48"

inherit pypi python_setuptools_build_meta

SRC_URI[md5sum] = "b458f1ceb9371d9d3051de2fd2c45bb8"
SRC_URI[sha256sum] = "8b536a8ec63dc0751342b3984193a3118f8fca2afe25752bb9b7fffd398552d3"

