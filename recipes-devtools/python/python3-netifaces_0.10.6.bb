inherit setuptools3
require python-netifaces.inc
