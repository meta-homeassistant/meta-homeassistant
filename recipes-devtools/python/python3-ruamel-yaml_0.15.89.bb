inherit setuptools3
require python-ruamel-yaml.inc
