inherit setuptools3
require python-yeelight.inc
