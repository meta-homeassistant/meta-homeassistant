inherit setuptools3
require python-pychromecast.inc
