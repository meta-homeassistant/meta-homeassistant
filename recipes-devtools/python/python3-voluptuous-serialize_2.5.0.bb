inherit setuptools3
require python-voluptuous-serialize.inc

SRC_URI[md5sum] = "8a0e27e1a06410f0300f4a1c476b93e4"
SRC_URI[sha256sum] = "5359f2e0a4f972ae03066e0777b4f0755c9226b2af099ca4fc55432efd1a447b"
LIC_FILES_CHKSUM = "file://LICENSE;md5=dab31a1d28183826937f4b152143a33f"
