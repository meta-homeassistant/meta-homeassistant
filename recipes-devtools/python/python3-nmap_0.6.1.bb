inherit setuptools3
require python-nmap.inc
