inherit setuptools
require python-nmap.inc
