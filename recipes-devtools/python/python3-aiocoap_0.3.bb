SUMMARY = "Python CoAP library"
HOMEPAGE = "https://github.com/chrysn/aiocoap"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=afaf767baa20ac524dc12f1071ca493a"

inherit pypi setuptools3

SRC_URI[md5sum] = "f5fed00767b4197f2fbaa0ff95cbbf78"
SRC_URI[sha256sum] = "402d4151db6d8d0b1d66af5b6e10e0de1521decbf12140637e5b8d2aa9c5aef6"
