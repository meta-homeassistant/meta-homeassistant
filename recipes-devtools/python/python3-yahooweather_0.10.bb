SUMMARY = "a Python module that provides an interface to the Yahoo! Weather RSS feed."
HOMEPAGE = "https://github.com/pvizeli/yahooweather"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=ef2dd6dab317a39a6b1e8e2469a238c2"

inherit pypi setuptools3

SRC_URI[md5sum] = "45d87b49bd6f412e0ed2e4fe4b52f2b6"
SRC_URI[sha256sum] = "eace866194cc2483002e10790a82460bb675e197dd321141a978ff3b9fad5d2f"
