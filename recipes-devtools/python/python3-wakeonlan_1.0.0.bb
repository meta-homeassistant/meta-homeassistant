inherit setuptools3
require python-wakeonlan.inc
