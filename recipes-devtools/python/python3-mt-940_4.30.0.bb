SUMMARY = "A library to parse MT940 files and returns smart Python collections for statistics and manipulation."
HOMEPAGE = "https://github.com/WoLpH/mt940"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=aaeffe87d7dfba78e04580907525ae7b"
RECIPE_MAINTAINER = "Tom Geelen <t.f.g.geelen@gmail.com>"

SRC_URI[sha256sum] = "da14e2ec84d6c6e85604d2a6b8a800b08ec6000351acde501c41eb662819295c"

inherit pypi setuptools3
