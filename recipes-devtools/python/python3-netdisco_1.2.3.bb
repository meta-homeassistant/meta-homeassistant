inherit setuptools3
require python-netdisco.inc
