inherit setuptools3
require python-importlib-metadata.inc
