inherit setuptools3
require python-roombapy.inc
