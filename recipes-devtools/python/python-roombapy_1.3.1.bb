inherit setuptools
require python-roombapy.inc
