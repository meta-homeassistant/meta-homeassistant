inherit setuptools3
require python-uritemplate.inc
