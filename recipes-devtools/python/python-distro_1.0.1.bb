inherit setuptools
require python-distro.inc
