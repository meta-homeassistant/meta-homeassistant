SUMMARY = "aiolifx light effectso"
HOMEPAGE = "https://github.com/amelchio/aiolifx_effects"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=751cf730c9b4efcac8032196afacf6f8"

PYPI_PACKAGE = "aiolifx_effects"

inherit pypi setuptools3

SRC_URI[md5sum] = "95a423f6cb022d06b6b5a04833c4fa0b"
SRC_URI[sha256sum] = "b0ba16e0b6f1cd2ed19924e951cfa285905beda6278b8afcf264325013da096a"
