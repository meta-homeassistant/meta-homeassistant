SUMMARY = "An implementation of the Debug Adapter Protocol for Python"
HOMEPAGE = "https://github.com/microsoft/debugpy/"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=7b6b095fe2a2e2b66cb08d295b605789"

SRC_URI[sha256sum] = "6ad2688b69235c43b020e04fecccdf6a96c8943ca9c2fb340b8adc103c655e57"

inherit pypi python_setuptools_build_meta
