SUMMARY = "Converts a Python dictionary or other native data type into a valid XML string."
HOMEPAGE = "https://github.com/quandyfactory/dicttoxml"
LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://LICENCE.txt;md5=8c6f370c9073badc24ad75afa6822bcb"
RECIPE_MAINTAINER = "Tom Geelen <t.f.g.geelen@gmail.com>"

SRC_URI[sha256sum] = "6f36ce644881db5cd8940bee9b7cb3f3f6b7b327ba8a67d83d3e2caa0538bf9d"

inherit pypi python_setuptools_build_meta
