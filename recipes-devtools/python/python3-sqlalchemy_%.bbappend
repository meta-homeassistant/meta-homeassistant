RDEPENDS:${PN} += "\
    python3-greenlet \
"