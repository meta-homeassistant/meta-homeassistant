inherit setuptools
require python-uritemplate.inc
