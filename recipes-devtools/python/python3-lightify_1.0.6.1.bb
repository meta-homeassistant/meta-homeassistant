inherit setuptools3
require python-lightify.inc
