SUMMARY = "An implementation of the WebSocket Protocol (RFC 6455)"
HOMEPAGE = "https://github.com/aaugustin/websockets"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d4ae7def6b740abc020a2700493fef4e"

inherit pypi setuptools3

SRC_URI[md5sum] = "c1842c03d14169082e065a109fe1cb2c"
SRC_URI[sha256sum] = "b536827d433a79e85108becdac0b0909e7ce02c3613df53da6d96aee950b50b5"
