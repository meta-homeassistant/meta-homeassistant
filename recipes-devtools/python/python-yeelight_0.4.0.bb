inherit setuptools
require python-yeelight.inc
