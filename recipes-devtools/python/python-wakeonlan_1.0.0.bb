inherit setuptools
require python-wakeonlan.inc
