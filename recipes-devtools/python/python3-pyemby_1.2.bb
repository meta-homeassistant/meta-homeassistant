inherit setuptools3
require python-pyemby.inc
