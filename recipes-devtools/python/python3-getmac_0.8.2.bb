SUMMARY = "Platform-independent pure-Python module to get a MAC address"
HOMEPAGE = "https://github.com/GhostofGoes/getmac"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=49206937513d48371c7b19babc4ec77f"

SRC_URI[md5sum] = "cf1af0d5c0e5d1fe7f62401bcb726a26"
SRC_URI[sha256sum] = "d501d20b71856248cfa07a8758192e86a01077910afb8b659a89946c4d52d368"

inherit pypi setuptools3
