SUMMARY = "Python Library to access AVM Fritz!Box homeautomation"
HOMEPAGE = "https://github.com/hthiery/python-fritzhome"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=01351c51c0264f1a06fee66797afb35a"

SRC_URI[md5sum] = "b264161a47d29253bcc4fd16a3ec12f3"
SRC_URI[sha256sum] = "276a75f6ce6363231a030bfc17922fefad7ceecb3d62df055114efb9bbb58981"

inherit pypi setuptools3
