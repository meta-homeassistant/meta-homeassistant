SUMMARY = "Open-source home automation platform running on Python 3."
HOMEPAGE = "https://github.com/Cereal2nd/pyDuotecno"
LICENSE = "Apache-2.0 & MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=86d3f3a95c324c9479bd8986968f4327"
RECIPE_MAINTAINER = "Tom Geelen <t.f.g.geelen@gmail.com>"

SRC_URI[sha256sum] = "5a31829a4c08bbe9a252209b6578c4e2c66386b53b35dbf056c2cbdd5853f861"

inherit pypi setuptools3
