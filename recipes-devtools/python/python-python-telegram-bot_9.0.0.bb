inherit setuptools
require python-python-telegram-bot.inc
