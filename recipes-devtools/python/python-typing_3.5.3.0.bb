inherit setuptools
require python-typing.inc
