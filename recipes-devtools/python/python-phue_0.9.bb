inherit setuptools
require python-phue.inc
