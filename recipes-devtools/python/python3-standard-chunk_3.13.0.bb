SUMMARY = "Standard library chunk redistribution. "dead battery"."
HOMEPAGE = "https://github.com/youknowone/python-deadlib"
LICENSE = "PSF-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=4e3cd541391435e0a82da0f9f489e85f"

SRC_URI[sha256sum] = "4ac345d37d7e686d2755e01836b8d98eda0d1a3ee90375e597ae43aaf064d654"

inherit pypi python_setuptools_build_meta

PYPI_PACKAGE = "standard_chunk"
