SUMMARY = "A JSON-RPC client library for asyncio"
HOMEPAGE = "http://github.com/armills/jsonrpc-async"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=9535ae79c9d2a6e803c0603c6e004747"

inherit pypi setuptools3

SRC_URI[md5sum] = "46d7697c554543fe083ea8e84163f36e"
SRC_URI[sha256sum] = "fcaf586593c90fd153a37f5d6133c8db286f4b48ee3f747dd3c44a53361e3738"
