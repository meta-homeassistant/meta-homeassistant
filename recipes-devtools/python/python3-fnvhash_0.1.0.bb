SUMMARY = "Pure Python FNV hash implementation"
HOMEPAGE = "https://github.com/znerol/py-fnvhash"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://README.rst;beginline=29;endline=29;md5=9fc306bc8bfce4375f3500f34cb73bb6"
RECIPE_MAINTAINER = "Tom Geelen <t.f.g.geelen@gmail.com>"

inherit pypi setuptools3

SRC_URI[md5sum] = "0d3a16ca83f2cb81a35889121c27a8fe"
SRC_URI[sha256sum] = "3e82d505054f9f3987b2b5b649f7e7b6f48349f6af8a1b8e4d66779699c85a8e"

