inherit setuptools
require python-lightify.inc
