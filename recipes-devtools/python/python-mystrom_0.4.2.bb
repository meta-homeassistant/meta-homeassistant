inherit setuptools
require python-mystrom.inc
