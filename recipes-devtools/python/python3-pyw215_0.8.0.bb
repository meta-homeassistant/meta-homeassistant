SUMMARY = "Interface for d-link W215 Smart Plugs."
HOMEPAGE = "https://github.com/linuxchristian/pyW215"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=8;endline=8;md5=8227180126797a0148f94f483f3e1489"
RECIPE_MAINTAINER = "Tom Geelen <t.f.g.geelen@gmail.com>"

SRC_URI[sha256sum] = "0104465e9b9db8744ca3311940c34b5f97f91ad25add3ff9ac7206a86bd650fe"

inherit pypi setuptools3
