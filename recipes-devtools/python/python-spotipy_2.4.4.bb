inherit setuptools
require python-spotipy.inc
