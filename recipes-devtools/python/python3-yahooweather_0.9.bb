inherit setuptools3
require python-yahooweather.inc

