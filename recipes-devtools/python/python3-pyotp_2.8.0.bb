SUMMARY = "Python One Time Password Library"
HOMEPAGE = "https://github.com/pyotp/pyotp"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f4889ab24aecac0a410d83c0323f9daf"

SRC_URI[sha256sum] = "c2f5e17d9da92d8ec1f7de6331ab08116b9115adbabcba6e208d46fc49a98c5a"

inherit pypi setuptools3
