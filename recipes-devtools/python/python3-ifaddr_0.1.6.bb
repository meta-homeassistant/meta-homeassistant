SUMMARY = "ifaddr is a small Python library that allows you to find all the \
IP addresses of the computer."
HOMEPAGE = "https://github.com/pydron/ifaddr"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://setup.py;md5=aa783d89d81cdd476e0742e298164716"

inherit pypi setuptools3

SRC_URI[md5sum] = "cc1b7f0a587ef38491f07e50bf91d82e"
SRC_URI[sha256sum] = "c19c64882a7ad51a394451dabcbbed72e98b5625ec1e79789924d5ea3e3ecb93"

