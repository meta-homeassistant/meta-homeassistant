SUMMARY = "Python wrapper for Fully Kiosk Browser REST API"
HOMEPAGE = "https://github.com/cgarwood/python-fullykiosk"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=8;endline=8;md5=23f9ad5cad3d8cc0336e2a5d8a87e1fa"
RECIPE_MAINTAINER = "Tom Geelen <t.f.g.geelen@gmail.com>"

SRC_URI[sha256sum] = "122012db6eac9cedf8e52b7b044a05bf87cba54a0a87ff89c47c0b49dacc539b"

inherit pypi setuptools3

PYPI_PACKAGE = "python-fullykiosk"
