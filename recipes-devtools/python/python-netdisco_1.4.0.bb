inherit setuptools
require python-netdisco.inc
