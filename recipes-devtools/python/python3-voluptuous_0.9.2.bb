inherit setuptools3
require python-voluptuous.inc
