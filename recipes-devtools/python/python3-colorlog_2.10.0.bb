inherit setuptools3
require python-colorlog.inc
