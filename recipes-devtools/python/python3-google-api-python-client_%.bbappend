RDEPENDS:${PN} += "\
    python3-google-auth-httplib2 \
"
