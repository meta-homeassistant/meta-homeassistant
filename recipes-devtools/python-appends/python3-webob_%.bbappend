RDEPENDS:${PN} += "python3-legacy-cgi"
