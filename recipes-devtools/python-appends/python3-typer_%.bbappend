RDEPENDS:${PN} += "\
    python3-annotated-doc \
    python3-rich \
    python3-shellingham \
"
