DEPENDS += "\
    python3-dunamai-native \
    python3-jinja2-native \
"
