RDEPENDS:${PN} += "python3-matplotlib-inline"