SUMMARY = "eBusd python integration library for HomeAssistant."
HOMEPAGE = "https://github.com/CrazYoshi/ebusdpy"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://setup.py;md5=0bbe0b14130f2efc2ae8a908a8b0b552"

inherit pypi setuptools3

SRC_URI[md5sum] = "606f485b35b01566f0d40dc1375a3259"
SRC_URI[sha256sum] = "f779090558d9e740d20c69e453d911a16fab11f65492b1d3af221222c1762b95"

