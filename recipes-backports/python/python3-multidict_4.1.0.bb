SUMMARY = "Multidicts are useful for working with HTTP headers, URL query args etc."
HOMEPAGE = "https://github.com/aio-libs/multidict/"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e74c98abe0de8f798ca609137f9cef4a"

inherit pypi setuptools3

SRC_URI[md5sum] = "c7e209d250ad7d2edf8364a2b3670052"
SRC_URI[sha256sum] = "fb4412490324705dcd2172baa8a3ea58ae23c5f982476805cad58ae929fe2a52"
