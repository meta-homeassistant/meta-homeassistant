IMAGE_INSTALL += "\ 
	mosquitto \
	swupdate \
	swupdate-progress \
	swupdate-www \
	swupdate-tools \
	"
