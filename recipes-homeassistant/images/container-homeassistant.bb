SUMMARY = "A small containr just capable of running Home Assistant"

IMAGE_INSTALL = "python3-homeassistant"

IMAGE_LINGUAS = " "

LICENSE = "MIT"

inherit image
inherit image-container

IMAGE_FSTYPES = " container"
