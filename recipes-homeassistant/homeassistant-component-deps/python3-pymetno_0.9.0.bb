SUMMARY = "Python library to talk to the met.no api"
HOMEPAGE = "https://github.com/Danielhiversen/pyMetno/"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=5d503272f52c35147ec960cb56a03bf4"

SRC_URI[md5sum] = "457f5d190c020884371671080fd2c3cf"
SRC_URI[sha256sum] = "9845a900577cea3803cb6002a1108bf1aab6c89fcff8d8fe46682351fb82a3ed"

PYPI_PACKAGE = "PyMetno"

inherit pypi setuptools3
