SUMMARY = "Convert Voluptuous schemas to dictionaries so they can be serialized."
HOMEPAGE = "https://github.com/bdraco/ulid-transform"
LICENSE = "MIT"

inherit setuptools3 pypi

PYPI_PACKAGE = "ulid_transform"

SRC_URI[sha256sum] = "2d1442c1f7b0f1ca7c0d6218315c45e709bcc029a49aae65d38391b9338c5f39"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d8b5b84f8af09011094cd7c29a9f972c"
