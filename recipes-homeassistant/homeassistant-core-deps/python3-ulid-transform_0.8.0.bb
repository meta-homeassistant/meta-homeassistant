SUMMARY = "Convert Voluptuous schemas to dictionaries so they can be serialized."
HOMEPAGE = "https://github.com/bdraco/ulid-transform"
LICENSE = "MIT"

inherit setuptools3 pypi

PYPI_PACKAGE = "ulid_transform"

SRC_URI[sha256sum] = "dde4daefe0b75d2d7e911ba6865585e40f46daa9bc8c01ef16979ae6953d3105"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d8b5b84f8af09011094cd7c29a9f972c"
