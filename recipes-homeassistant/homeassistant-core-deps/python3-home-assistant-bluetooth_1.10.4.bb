SUMMARY = "Basic bluetooth models used by Home Assistant."
HOMEPAGE = "https://pypi.org/project/home-assistant-bluetooth/"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=732518afbb3ba92dbf606e49f9045cc9"

PYPI_PACKAGE = "home_assistant_bluetooth"

inherit pypi setuptools3

SRC_URI[sha256sum] = "21216b6be9d028bc232b9188ac4dce773798c6b4e47482cc3524bfc5f82515e3"

