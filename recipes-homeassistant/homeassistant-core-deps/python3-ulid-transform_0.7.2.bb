SUMMARY = "Convert Voluptuous schemas to dictionaries so they can be serialized."
HOMEPAGE = "https://github.com/bdraco/ulid-transform"
LICENSE = "MIT"

inherit setuptools3 pypi

PYPI_PACKAGE = "ulid_transform"

SRC_URI[sha256sum] = "5f78a9f9e7f71bb775cb74c2b4b2f085ddcf556c925d7d56d2d2e401bea6af5b"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d8b5b84f8af09011094cd7c29a9f972c"
