SUMMARY = "Convert Voluptuous schemas to dictionaries so they can be serialized."
HOMEPAGE = "https://github.com/bdraco/ulid-transform"
LICENSE = "MIT"

inherit setuptools3 pypi

PYPI_PACKAGE = "ulid_transform"

SRC_URI[sha256sum] = "a7644888bd174791f85f6edd1a85cb8ef6faa3cb8e508445464c49d8d208511f"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d8b5b84f8af09011094cd7c29a9f972c"
