SUMMARY = "Basic bluetooth models used by Home Assistant."
HOMEPAGE = "https://pypi.org/project/home-assistant-bluetooth/"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=732518afbb3ba92dbf606e49f9045cc9"

PYPI_PACKAGE = "home_assistant_bluetooth"

inherit pypi setuptools3

SRC_URI[sha256sum] = "46f4403959911a2eed071bcbf7a076babcf677d140e731dbb01d3f23588fc98d"

