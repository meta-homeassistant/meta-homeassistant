SUMMARY = "Basic bluetooth models used by Home Assistant."
HOMEPAGE = "https://pypi.org/project/home-assistant-bluetooth/"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=732518afbb3ba92dbf606e49f9045cc9"

PYPI_PACKAGE = "home_assistant_bluetooth"

inherit pypi setuptools3

SRC_URI[sha256sum] = "e810a2db9d3d542779c46a4202fb3f1de54692e2631257a00b8aa2634c7ebde0"

