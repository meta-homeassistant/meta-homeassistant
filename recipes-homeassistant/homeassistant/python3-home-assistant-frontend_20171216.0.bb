SUMMARY = "The Home Assistant frontend"
HOMEPAGE = "https://github.com/home-assistant/home-assistant-polymer"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=f4eda51018051de136d3b3742e9a7a40"

inherit pypi setuptools3

SRC_URI[md5sum] = "fb0385660cdfa29907e8be6534daaa1b"
SRC_URI[sha256sum] = "426743ed53508617a8db168e01152b1fe1c004c09de2e855e3f86697c6744148"
