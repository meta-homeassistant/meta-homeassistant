SUMMARY = "The Home Assistant frontend"
HOMEPAGE = "https://github.com/home-assistant/home-assistant-polymer"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=f4eda51018051de136d3b3742e9a7a40"

inherit pypi setuptools3

SRC_URI[md5sum] = "585c3d3c61cc13bc22dd64e1239dcca8"
SRC_URI[sha256sum] = "e0d7b88510b31b91614e8770f20866eb3830799c155208765a79665f0a1330ad"
