inherit setuptools
require python-pytest-runner.inc
