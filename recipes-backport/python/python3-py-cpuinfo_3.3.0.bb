inherit setuptools3
require python-py-cpuinfo.inc
