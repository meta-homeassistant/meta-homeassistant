RDEPENDS:${PN}:append = "\
    python3-simple-websocket \
"
